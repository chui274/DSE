# Keil uVision project ProyectoFinal_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-035 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: ProyectoFinal_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h ADC.c ADC.h ADC_PM.c ADC_INT.c pot.c pot.h pot_aliases.h PWM.c PWM.h PWM_PM.c Clock.c Clock.h LCD.c LCD.h LCD_PM.c Pulse.c Pulse.h Pulse_aliases.h Trig.c Trig.h Trig_aliases.h TimeDistMeas.c TimeDistMeas.h TimeDistMeas_PM.c Triggen.h Triggen.c Triggen_PM.c Clock_1.c Clock_1.h DistOutHCSRO4.c DistOutHCSRO4.h DistOutHCSRO4_aliases.h ADC_AMux.c ADC_AMux.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_IRQ.c ADC_IRQ.h ADC_theACLK.c ADC_theACLK.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-035 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: ProyectoFinal_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
